# Keil uVision project FreeRtos.uvprojx, settings and files
target Source (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\..\project;..\..\lib\CMSIS\CM3\CoreSupport;..\..\lib\STM32F10x_StdPeriph_Driver\inc;..\..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\..\myLibrary;..\..\freeRtos;..\..\freeRtos\include;..\..\freeRtos\portable;..\..\freeRtos\portable\MemMang;..\..\freeRtos\portable\RVDS;..\..\freeRtos\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_bkp.c
  group user
    ../: main.c stm32f10x_it.c system_stm32f10x.c
  group myLib
    ../../myLibrary/: appTimeManage.c Button.c DelayTimer.c dht11.c LCD_I2C.c rtc.c appServo.c light.c RingBuffer.c Serial.c
  group freeRtos
    ../../freertos/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
